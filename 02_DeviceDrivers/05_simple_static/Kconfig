## 02_DeviceDrivers/05_simple_static/Kconfig
```kconfig
menu "SIMPLE DRIVER"
config SIMPLE
	tristate "simple driver"
	---help---
	this is a simple export module
endmenu
```
